# Enable alsa and gstreamer
PACKAGECONFIG = " gstreamer"

DEPENDS += "gstreamer1.0-plugins-good gstreamer1.0-plugins-bad gstreamer1.0-plugins-ugly"
